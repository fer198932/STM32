# Keil uVision project OIMRobot.uvprojx, settings and files
target OIMRobot (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OIMRobot +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LIMIT;..\HARDWARE\DMA;..\HARDWARE\BUFFER;..\MALLOC;..\HARDWARE\EXTI;..\HARDWARE\PWM;..\HARDWARE\TIMER;..\HARDWARE\StepMotor
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c macro_operate.c ComDataProc.c command.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LIMIT/: limit_IO.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/BUFFER/: buffer.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/StepMotor/: StepMotor.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group MALLOC
    ../MALLOC/: malloc.c
